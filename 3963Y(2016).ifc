Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-25T15:50:58
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 25 15:50:58 2019 * Host: DESKTOP-23GQEAI * Database: C:\Users\vladb\AppData\Local\Temp\{7D602DCE-FDC5-4F87-B352-CF1D41A86A58}\ifc * Database version: 5507 * Database creation date: Mon Mar 25 15:50:57 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 25 15:50:57 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 25 15:50:57 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 3963Y Shower faucet, 3963Y(2016):3963Y Shower faucet:328658
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 145.3 mm; NominalHeight: 122.7 mm; NominalWidth: 220.3 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 3963Y(2016); ConvergoRefNr: 0087-1803-0064-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 20/03/2019
Type - Green Building Properties(Type) - Approval ABP: PA-IX 29207/IB; Approval KIWA SE Type Approval: 1446; Customs Code: 84818011; EAN Number: 6414150080982; URL ABP: http://static.oras.com/ABP/3963Y; URL KIWA SE Type Approval: http://static.oras.com/SETypeApproval/3963Y
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/3963Y; Catalog Drawing URL: http://static.oras.com/catdrw/3963Y; Class: Single lever; Dimension Drawing URL: http://static.oras.com/dimdrw/3963Y; FDV Document URL: http://www.oras.com/datasheet/3963Y/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/3963Y; Group: Shower faucets; Long Marketing: Shower faucet with eccentric unions 150 cc and cover plates. There are also in-built limitation options for water temperature and maximum flow-rate.; Manufacturer: Oras; Market: INT;POL;UKR;LTU;LVA;RUS; Model: 3963Y Shower faucet; Name_en: 3963Y Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 200 x 165 x 95; Package Weight: 1.465 kg; Product Code: 3960Y; Product Datasheet: http://www.oras.com/datasheet/3963Y/en; Product Family: Oras Saga; Product Image URL: http://static.oras.com/image/3963Y; Product URL: http://static.oras.com/3963Y; Type Name: 3963Y Shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Flow Rate At 300kPa: 0.00953496 m3/s; Installation and Maintenance: http://static.oras.com/manual/3963Y; Installation Type: Wall-mounted; Installation Width: cc150 mm; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 165000 Pa
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3963Y(2016); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3963Y; Name: 3963Y Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 220x145x120 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3963Y; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3963Y Shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0788494 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00393822 m3
Identity Data - Mark: 10
Mechanical - System Classification: Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 3963Y(2016): 3963Y Shower faucet; Family and Type: 3963Y(2016): 3963Y Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3963Y(2016): 3963Y Shower faucet; Type Id: 3963Y(2016): 3963Y Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
